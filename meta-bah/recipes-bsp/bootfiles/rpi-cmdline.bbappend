CMDLINE:append = " snd_bcm2835.enable_headphones=1 snd_bcm2835.enable_hdmi=0"
