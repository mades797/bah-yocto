RDEPENDS:${PN}:remove:rpi = "rpi-gpio"
