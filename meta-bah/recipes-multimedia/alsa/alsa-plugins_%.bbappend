PACKAGECONFIG:append:raspberrypi0-2w = " samplerate"
