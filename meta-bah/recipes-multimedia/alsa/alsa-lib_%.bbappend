EXTRA_OECONF:append:raspberrypi0-2w = " --with-softfloat"
